<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zmq_subscriber_w_qtgui</value></param>
<param><key>author</key><value>Hans Erik Fjeld</value></param>
<param><key>description</key><value>Connect to a an instance running a non GUI RF frontend</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>GUI for connecting with Limesdr instance</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_len</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>16e6</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>data_len</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_scope_sink</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>data_len</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Frequency</value></param>
<param><key>label1</key><value>Time</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zmq_qt_rx_subscriber</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5001</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zmq_tx_sub</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_scope_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>qtgui_freq_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>qtgui_scope_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zmq_qt_rx_subscriber</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zmq_tx_sub</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
